# Keil uVision project uCOS-II.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: uCOS-II +hex
  c flags: Optim=1
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x33000000 size 0x3d09000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --first STARTUP.o
  group includes
    ./src/includes/: dataformat.h includes.h OS_CFG.H OS_CPU.H ucos_ii.h usr_includes.h
  group cpu
    ./src/cpu/: OS_CPU_A.S OS_CPU_C.C STARTUP.S
  group os
    ./src/os/: ucos_ii.c
  group usr
    ./src/usr/: logger.c SYSTEM_CODE.C UTILS_A.S UTILS_C.C
